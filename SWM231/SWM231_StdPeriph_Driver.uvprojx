# Keil uVision project SWM231_StdPeriph_Driver.uvprojx, settings and files
target SWM231 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM231x6 Synwit
  pack: Synwit.SWM32_New.0.2.6
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SWM231_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=3 v6LangP=1
  c define: CHIP_SWM231, ITERATIONS=1000
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM231_StdPeriph_Driver;..\coremark;.\APP
  asm define: CHIP_SWM231
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ./app/: main.c
    ./APP/: core_portme.c
  group coremark
    ../coremark/: core_main.c core_matrix.c core_state.c core_util.c core_list_join.c
  group CSL\StdPD
    ./CSL/SWM231_StdPeriph_Driver/: SWM231_port.c SWM231_gpio.c SWM231_exti.c SWM231_timr.c SWM231_uart.c SWM231_adc.c SWM231_pwm.c SWM231_wdt.c SWM231_div.c SWM231_spi.c SWM231_dma.c SWM231_flash.c SWM231_iofilt.c SWM231_foc.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM231.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM231.s
